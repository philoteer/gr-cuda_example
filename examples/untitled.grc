options:
  parameters:
    generate_options: qt_gui
    id: foo
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1048576'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1048576'
    type: complex
  states: {}
- name: cuda_example_cuda_cpp_mul2_0
  id: cuda_example_cuda_cpp_mul2
  parameters:
    device_num: '0'
    vlen: '1048576'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: Multiplied (I)
    label2: Multiplied (Q)
    nconnections: '2'
    size: '32'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_stream_to_vector_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_stream_to_vector_0, '0', cuda_example_cuda_cpp_mul2_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_null_sink_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']
- [cuda_example_cuda_cpp_mul2_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
